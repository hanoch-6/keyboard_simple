# Repository hanoch-6/keyboard_simple

## KiCad design hardware/keyboard_simple.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric
C2, C3, C4, C5, C6, C7: 0.1uF; C_0603_1608Metric
C8, C9, C13, C15: 22pF; C_0603_1608Metric
C10, C11: 104; C_0603_1608Metric
C12: 10uF; C_1206_3216Metric
C14: 1uF; C_0603_1608Metric
C16, C17: 4.7nF; C_0603_1608Metric
C18: C; C_0603_1608Metric
D1, D3: LED; LED_0805_2012Metric
D5: 1N4148W; D_SOD-123
J1, J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J3: Conn_02x09_Odd_Even; PinHeader_2x09_P2.54mm_Vertical_SMD
J5: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J6: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J7: FPC; FPC-0.5mm-6PIN
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40: WS2812B-2020; LED_WS2812B-B; Manufacturer_Part_Number WS2812B-2020
Q1: S8050; SOT-23
Q2: S8550; SOT-23
R1, R4: 10k; R_0603_1608Metric
R2, R5, R15: 2k; R_0603_1608Metric
R3, R9, R10: 10K; R_0603_1608Metric
R6, R7: 22; R_0603_1608Metric
R8: 1.5K; R_0603_1608Metric
R11, R12, R13: 1k; R_0603_1608Metric
R14: 20; R_0603_1608Metric
R16, R17: 1K; R_0603_1608Metric
RN1, RN2, RN3, RN4, RN5, RN6: 10K; R_Array_Convex_8x0602
RN7: R_Pack04; R_Array_Convex_4x0603
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20, S21, S22, S23, S24, S25, S26, S27, S28, S29, S30, S31, S32, S33, S34, S35, S36, S37, S38, S39, S40: SW_Push; CHERRY-MX-LED+
SW1: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1, U2, U3, U4, U6, U7: 74HC165; SOIC127P600X175-16N
U5: STM32F103RBTx; LQFP-64_10x10mm_P0.5mm
U8: XC6210B332MR; SOT-23-5
U9: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
U10: XW06A; SOIC-16_3.9x9.9mm_P1.27mm
Y1: 8M; Crystal_SMD_Qantek_QC5CB-2Pin_5x3.2mm
Y2: 12M; Crystal_SMD_Qantek_QC5CB-2Pin_5x3.2mm

Connections:
/3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, C11.1, C12.1, J5.1, J6.1, J6.2, LED1.4 (VDD), LED2.4 (VDD), LED3.4 (VDD), LED4.4 (VDD), LED5.4 (VDD), LED6.4 (VDD), LED7.4 (VDD), LED8.4 (VDD), LED9.4 (VDD), LED10.4 (VDD), LED11.4 (VDD), LED12.4 (VDD), LED13.4 (VDD), LED14.4 (VDD), LED15.4 (VDD), LED16.4 (VDD), LED17.4 (VDD), LED18.4 (VDD), LED19.4 (VDD), LED20.4 (VDD), LED21.4 (VDD), LED22.4 (VDD), LED23.4 (VDD), LED24.4 (VDD), LED25.4 (VDD), LED26.4 (VDD), LED27.4 (VDD), LED28.4 (VDD), LED29.4 (VDD), LED30.4 (VDD), LED31.4 (VDD), LED32.4 (VDD), LED33.4 (VDD), LED34.4 (VDD), LED35.4 (VDD), LED36.4 (VDD), LED37.4 (VDD), LED38.4 (VDD), LED39.4 (VDD), LED40.4 (VDD), Q2.1 (E), R3.2, R8.1, R9.1, R10.1, R11.2, R14.2, RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), RN6.1 (common), U1.16 (VCC), U2.16 (VCC), U3.16 (VCC), U4.16 (VCC), U5.1 (VBAT), U5.13 (VDDA), U5.19 (VDD), U5.32 (VDD), U5.48 (VDD), U5.64 (VDD), U6.16 (VCC), U7.16 (VCC), U8.5 (VOUT), U9.16 (VCC)
/5V: C14.2, JP1.2 (B), JP2.2 (B), U8.1 (VIN), U8.3 (CE)
/BOOT0: J6.3, J6.5, R15.2, U5.60 (BOOT0)
/BOOT1: J6.4, J6.6, U5.28 (PB2)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, C16.2, C17.2, C18.2, D1.1 (K), D3.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.4, J6.7, J6.8, LED1.2 (GND), LED2.2 (GND), LED3.2 (GND), LED4.2 (GND), LED5.2 (GND), LED6.2 (GND), LED7.2 (GND), LED8.2 (GND), LED9.2 (GND), LED10.2 (GND), LED11.2 (GND), LED12.2 (GND), LED13.2 (GND), LED14.2 (GND), LED15.2 (GND), LED16.2 (GND), LED17.2 (GND), LED18.2 (GND), LED19.2 (GND), LED20.2 (GND), LED21.2 (GND), LED22.2 (GND), LED23.2 (GND), LED24.2 (GND), LED25.2 (GND), LED26.2 (GND), LED27.2 (GND), LED28.2 (GND), LED29.2 (GND), LED30.2 (GND), LED31.2 (GND), LED32.2 (GND), LED33.2 (GND), LED34.2 (GND), LED35.2 (GND), LED36.2 (GND), LED37.2 (GND), LED38.2 (GND), LED39.2 (GND), LED40.2 (GND), R1.2, R4.2, S33.1, S34.1, S35.1, S36.1, S37.1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
/PA2: J2.1, U5.16 (PA2)
/PA3: J2.2, U5.17 (PA3)
/PA4: J2.3, U5.20 (PA4)
/PA7: J2.4, U5.23 (PA7)
/PA8: J2.5, U5.41 (PA8)
/PA15: J2.6, U5.50 (PA15)
/PB0: J2.7, U5.26 (PB0)
/PB1: J2.8, U5.27 (PB1)
/PB3: J2.9, U5.55 (PB3)
/PB4: J2.10, U5.56 (PB4)
/PB5: J2.11, U5.57 (PB5)
/PB6: J2.12, U5.58 (PB6)
/PB7: J2.13, U5.59 (PB7)
/PB8: J2.14, U5.61 (PB8)
/PB9: J2.15, U5.62 (PB9)
/PB10: J2.16, U5.29 (PB10)
/PB11: J2.17, U5.30 (PB11)
/PB12: J2.18, U5.33 (PB12)
/PB14: J3.1, U5.35 (PB14)
/PC0: J3.2, U5.8 (PC0)
/PC1: J3.3, U5.9 (PC1)
/PC2: J3.4, U5.10 (PC2)
/PC3: J3.5, U5.11 (PC3)
/PC4: J3.6, U5.24 (PC4)
/PC5: J3.7, U5.25 (PC5)
/PC6: J3.8, U5.37 (PC6)
/PC7: J3.9, U5.38 (PC7)
/PC8: J3.10, U5.39 (PC8)
/PC9: J3.11, U5.40 (PC9)
/PC10: J3.12, U5.51 (PC10)
/PC11: J3.13, U5.52 (PC11)
/PC12: J3.14, U5.53 (PC12)
/PC13: J3.15, U5.2 (PC13)
/PC14: J3.16, U5.3 (PC14)
/PC15: J3.17, U5.4 (PC15)
/PD2: J3.18, U5.54 (PD2)
/RST: C7.1, D5.2 (A), R3.1, SW1.2, U5.7 (NRST)
/SCAN_CE: U1.15 (C_INH), U2.15 (C_INH), U3.15 (C_INH), U4.15 (C_INH), U5.15 (PA1), U6.15 (C_INH), U7.15 (C_INH)
/SCAN_PL: U1.1 (LAT), U2.1 (LAT), U3.1 (LAT), U4.1 (LAT), U5.14 (PA0), U6.1 (LAT), U7.1 (LAT)
/SPI2_CLK: U5.34 (PB13)
/SPI2_MOSI: LED1.3 (DI), U5.36 (PB15)
/SPI_1CLK: U1.2 (CLK), U2.2 (CLK), U3.2 (CLK), U4.2 (CLK), U5.21 (PA5), U6.2 (CLK), U7.2 (CLK)
/SPI_1MISO: U1.9 (QH), U5.22 (PA6)
/SPI_KEY1: LED9.1 (DO), LED10.3 (DI)
/SPI_KEY2: LED18.1 (DO), LED19.3 (DI)
/SPI_KEY3: LED27.1 (DO), LED28.3 (DI)
/SPI_KEY4: LED36.1 (DO), LED37.3 (DI)
/SWCLK: J5.3, R10.2, U5.49 (PA14)
/SWDIO: J5.2, R9.2, U5.46 (PA13)
/USART1_RX: U5.42 (PA9), U9.2 (TXD)
/USART1_TX: U5.43 (PA10), U9.3 (RXD)
/USB_D+: J1.A6 (D+), J1.B6 (D+), U9.5 (UD+)
/USB_D-: J1.A7 (D-), J1.B7 (D-), U9.6 (UD-)
/USB_DEVICE+: R7.1, U5.45 (PA12)
/USB_DEVICE-: R6.1, U5.44 (PA11)
/serial: U4.10 (SER), U6.9 (QH)
unnamed: C8.1, U5.5 (PD0), Y1.1
unnamed: C9.1, U5.6 (PD1), Y1.2
unnamed: C13.2, U9.7 (XI), Y2.1
unnamed: C15.2, U9.8 (XO), Y2.2
unnamed: C16.1, R14.1, U10.16 (VDD)
unnamed: C17.1, U10.2 (C1)
unnamed: C18.1, U10.3 (CSEL)
unnamed: D1.2 (A), R2.2
unnamed: D3.2 (A), R5.2
unnamed: D5.1 (K), Q1.3 (C), R11.1
unnamed: J1.A4 (VBUS), J1.A8 (SBU1), J1.A9 (VBUS), J1.B4 (VBUS), J1.B8 (SBU2), J1.B9 (VBUS), JP1.1 (A), R2.1
unnamed: J1.A5 (CC1), J1.B5 (CC2), R1.1
unnamed: J4.A4 (VBUS), J4.A8 (SBU1), J4.A9 (VBUS), J4.B4 (VBUS), J4.B8 (SBU2), J4.B9 (VBUS), JP2.1 (A), R5.1
unnamed: J4.A5 (CC1), J4.B5 (CC2), R4.1
unnamed: J4.A6 (D+), J4.B6 (D+), R7.2, R8.2
unnamed: J4.A7 (D-), J4.B7 (D-), R6.2
unnamed: J7.1, RN7.5 (R4.2)
unnamed: J7.2, RN7.6 (R3.2)
unnamed: J7.3, RN7.7 (R2.2)
unnamed: J7.4, RN7.8 (R1.2)
unnamed: J7.5, R16.1
unnamed: J7.6, R17.1
unnamed: LED1.1 (DO), LED2.3 (DI)
unnamed: LED2.1 (DO), LED3.3 (DI)
unnamed: LED3.1 (DO), LED4.3 (DI)
unnamed: LED4.1 (DO), LED5.3 (DI)
unnamed: LED5.1 (DO), LED6.3 (DI)
unnamed: LED6.1 (DO), LED7.3 (DI)
unnamed: LED7.1 (DO), LED8.3 (DI)
unnamed: LED8.1 (DO), LED9.3 (DI)
unnamed: LED10.1 (DO), LED11.3 (DI)
unnamed: LED11.1 (DO), LED12.3 (DI)
unnamed: LED12.1 (DO), LED13.3 (DI)
unnamed: LED13.1 (DO), LED14.3 (DI)
unnamed: LED14.1 (DO), LED15.3 (DI)
unnamed: LED15.1 (DO), LED16.3 (DI)
unnamed: LED16.1 (DO), LED17.3 (DI)
unnamed: LED17.1 (DO), LED18.3 (DI)
unnamed: LED19.1 (DO), LED20.3 (DI)
unnamed: LED20.1 (DO), LED21.3 (DI)
unnamed: LED21.1 (DO), LED22.3 (DI)
unnamed: LED22.1 (DO), LED23.3 (DI)
unnamed: LED23.1 (DO), LED24.3 (DI)
unnamed: LED24.1 (DO), LED25.3 (DI)
unnamed: LED25.1 (DO), LED26.3 (DI)
unnamed: LED26.1 (DO), LED27.3 (DI)
unnamed: LED28.1 (DO), LED29.3 (DI)
unnamed: LED29.1 (DO), LED30.3 (DI)
unnamed: LED30.1 (DO), LED31.3 (DI)
unnamed: LED31.1 (DO), LED32.3 (DI)
unnamed: LED32.1 (DO), LED33.3 (DI)
unnamed: LED33.1 (DO), LED34.3 (DI)
unnamed: LED34.1 (DO), LED35.3 (DI)
unnamed: LED35.1 (DO), LED36.3 (DI)
unnamed: LED37.1 (DO), LED38.3 (DI)
unnamed: LED38.1 (DO), LED39.3 (DI)
unnamed: LED39.1 (DO), LED40.3 (DI)
unnamed: Q1.1 (E), R13.2, U9.14 (~RTS)
unnamed: Q1.2 (B), R12.1
unnamed: Q2.2 (B), R13.1
unnamed: Q2.3 (C), R15.1
unnamed: R12.2, U9.13 (~DTR)
unnamed: R16.2, U10.8 (PAD4)
unnamed: R17.2, U10.9 (PAD5)
unnamed: RN1.2 (R1), S8.2, U4.11 (D0)
unnamed: RN1.3 (R2), S7.2, U4.12 (D1)
unnamed: RN1.4 (R3), S6.2, U4.13 (D2)
unnamed: RN1.5 (R4), S5.2, U4.14 (D3)
unnamed: RN1.6 (R5), S4.2, U4.3 (D4)
unnamed: RN1.7 (R6), S3.2, U4.4 (D5)
unnamed: RN1.8 (R7), S2.2, U4.5 (D6)
unnamed: RN1.9 (R8), S1.2, U4.6 (D7)
unnamed: RN2.2 (R1), S16.2, U1.11 (D0)
unnamed: RN2.3 (R2), S15.2, U1.12 (D1)
unnamed: RN2.4 (R3), S14.2, U1.13 (D2)
unnamed: RN2.5 (R4), S13.2, U1.14 (D3)
unnamed: RN2.6 (R5), S12.2, U1.3 (D4)
unnamed: RN2.7 (R6), S11.2, U1.4 (D5)
unnamed: RN2.8 (R7), S10.2, U1.5 (D6)
unnamed: RN2.9 (R8), S9.2, U1.6 (D7)
unnamed: RN3.2 (R1), S24.2, U2.11 (D0)
unnamed: RN3.3 (R2), S23.2, U2.12 (D1)
unnamed: RN3.4 (R3), S22.2, U2.13 (D2)
unnamed: RN3.5 (R4), S21.2, U2.14 (D3)
unnamed: RN3.6 (R5), S20.2, U2.3 (D4)
unnamed: RN3.7 (R6), S19.2, U2.4 (D5)
unnamed: RN3.8 (R7), S18.2, U2.5 (D6)
unnamed: RN3.9 (R8), S17.2, U2.6 (D7)
unnamed: RN4.2 (R1), S32.2, U3.11 (D0)
unnamed: RN4.3 (R2), S31.2, U3.12 (D1)
unnamed: RN4.4 (R3), S30.2, U3.13 (D2)
unnamed: RN4.5 (R4), S29.2, U3.14 (D3)
unnamed: RN4.6 (R5), S28.2, U3.3 (D4)
unnamed: RN4.7 (R6), S27.2, U3.4 (D5)
unnamed: RN4.8 (R7), S26.2, U3.5 (D6)
unnamed: RN4.9 (R8), S25.2, U3.6 (D7)
unnamed: RN5.5 (R4), S37.2, U6.14 (D3)
unnamed: RN5.6 (R5), S36.2, U6.3 (D4)
unnamed: RN5.7 (R6), S35.2, U6.4 (D5)
unnamed: RN5.8 (R7), S34.2, U6.5 (D6)
unnamed: RN5.9 (R8), S33.2, U6.6 (D7)
unnamed: RN6.2 (R1), RN6.3 (R2), S39.2, S40.2, U7.11 (D0), U7.12 (D1)
unnamed: RN6.4 (R3), U7.13 (D2), U10.10 (OUT5)
unnamed: RN6.5 (R4), U7.14 (D3), U10.11 (OUT4)
unnamed: RN6.6 (R5), U7.3 (D4), U10.12 (OUT3)
unnamed: RN6.7 (R6), U7.4 (D5), U10.13 (OUT2)
unnamed: RN6.8 (R7), U7.5 (D6), U10.14 (OUT1)
unnamed: RN6.9 (R8), U7.6 (D7), U10.15 (OUT0)
unnamed: RN7.1 (R1.1), U10.7 (PAD3)
unnamed: RN7.2 (R2.1), U10.6 (PAD2)
unnamed: RN7.3 (R3.1), U10.5 (PAD1)
unnamed: RN7.4 (R4.1), U10.4 (PAD0)
unnamed: S1.1, S2.1, S3.1, S4.1, S5.1, S6.1, S7.1, S8.1
unnamed: S9.1, S10.1, S11.1, S12.1, S13.1, S14.1, S15.1, S16.1
unnamed: S17.1, S18.1, S19.1, S20.1, S21.1, S22.1, S23.1, S24.1
unnamed: S25.1, S26.1, S27.1, S28.1, S29.1, S30.1, S31.1, S32.1
unnamed: S38.2, U6.13 (D2)
unnamed: U1.10 (SER), U2.9 (QH)
unnamed: U2.10 (SER), U3.9 (QH)
unnamed: U3.10 (SER), U4.9 (QH)
unnamed: U6.10 (SER), U7.9 (QH)

Notes on the sheet:
USB转UART,CH340
BOOT控制器
USB
5V to 3.3V
串口调试口
ST-LINK下载口

Board: 2 copper layers, 148 parts (37 on the bottom side), 175 nets, no tracks yet.

## Commit log

2023-04-02 gitignore
2023-04-05 layout doing
